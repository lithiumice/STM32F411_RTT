# IAR project Backup (2) of project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F411xE; __RTTHREAD__; RT_USING_DLIBC; USE_HAL_DRIVER; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: rt-thread\include; rt-thread\components\net\lwip-2.0.2\src; rt-thread\components\cplusplus; rt-thread\components\finsh; board\CubeMX_Config\Inc; rt-thread\components\drivers\spi; libraries\HAL_Drivers\config; libraries\HAL_Drivers; rt-thread\components\net\lwip-2.0.2\src\include\ipv4; rt-thread\libcpu\arm\common; rt-thread\components\net\lwip-2.0.2\src\arch\include; .; rt-thread\components\drivers\include; board; rt-thread\components\libc\compilers\dlib; libraries\STM32F4xx_HAL\CMSIS\Include; rt-thread\components\net\lwip-2.0.2\src\include\posix; board\ports; rt-thread\libcpu\arm\cortex-m4; applications; rt-thread\components\net\lwip-2.0.2\src\include\netif; libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include; libraries\MyHalLibs; rt-thread\components\libc\compilers\common; libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc; libraries\TFTdisplay; rt-thread\components\net\lwip-2.0.2\src\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: MillisTaskManager.cpp my_math.cpp util.cpp main.cpp
  group CPlusPlus
    rt-thread/components/cplusplus/: cxx_Thread.cpp cxx_Semaphore.cpp cxx_Mutex.cpp cxx_crt.cpp crt_init.c
  group CPU
    rt-thread/libcpu/arm/common/: showmem.c backtrace.c div0.c
    rt-thread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/src/: ringblk_buf.c pipe.c workqueue.c dataqueue.c ringbuffer.c completion.c waitqueue.c
  group Drivers
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f411xe.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c drv_spi.c drv_gpio.c drv_usart.c drv_common.c drv_spi.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c
  group Kernel
    rt-thread/src/: idle.c kservice.c ipc.c components.c device.c timer.c object.c mem.c irq.c scheduler.c mempool.c clock.c thread.c
  group libc
    rt-thread/components/libc/compilers/common/: time.c stdlib.c
    rt-thread/components/libc/compilers/dlib/: syscalls.c syscall_read.c syscall_mem.c syscall_remove.c syscall_close.c libc.c syscall_write.c syscall_open.c environ.c stdio.c syscall_lseek.c
  group lwIP
    rt-thread/components/net/lwip-2.0.2/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c
    rt-thread/components/net/lwip-2.0.2/src/core/: ip.c netif.c sys.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c tcp_in.c dns.c timeouts.c udp.c pbuf.c def.c tcp.c
    rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
    rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
  group STM32_HAL
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_usart.c stm32f4xx_hal_cec.c stm32f4xx_hal_i2c.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_crc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_usart.c stm32f4xx_hal_cec.c stm32f4xx_hal_i2c.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_crc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_gpio.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c system_stm32f4xx.c
  group TFTdisplay
    libraries/TFTdisplay/: SPI.c GUI.c LCD.c
